# Keil uVision project VTOS_DEMO.uvprojx, settings and files
target VRTOS_DEMO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VTOS_DEMO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\..\user_lib\;..\..\user_lib\link_list;..\..\user_lib\message;..\..\user_lib\task;..\..\user_lib\timer;..\..\user_lib\debug;..\..\user_component\led;..\..\user_lib\vrtos;..\..\user_component\pwr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c main.c stm32l1xx_hal_msp.c usart.c stm32l1xx_it.c dma.c tim.c
    ../../user_component/led/: app_led.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_gpio.c stm32l1xx_hal_uart.c stm32l1xx_hal_dma.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash_ramfunc.c
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group New Group
    ../../user_lib/link_list/: queue_mgr.c
    ../../user_lib/debug/: app_trace.c
    ../../user_lib/vrtos/: vrtos.c
software components: CMSIS:CORE 4.1.0
